# Keil uVision project lab1.uvproj, settings and files
target helloWorld (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: lab1 +hex
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\CORE;.\FreeRTOS\include;.\STM32F1xx_Driver\inc;.\FreeRTOS\portable\RVDS\ARM_CM3;.\SYSTEM\sys;.\SYSTEM\SYSTEM;.\SYSTEM\delay;.\HARDWARE\LED;.\HARDWARE\OLED;..\lab_1;.\SYSTEM\show
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group MAIN
    ./: main.c playSong.c button.c button.h UART.c UART.h
  group CORE
    ./CORE/: startup_stm32f10x_hd.s core_cm3.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/SYSTEM/: system.c
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/show/: show.c
  group HARDWARE
    ./HARDWARE/OLED/: oled.c
    ./HARDWARE/LED/: LED.C
    ./: buzzer.h BUZZER.c
  group FREERTOS
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ./FreeRTOS/portable/MemMang/: heap_4.c
    ./FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group STM32F1xx_Driver
    ./STM32F1xx_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
